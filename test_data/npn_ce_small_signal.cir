rpi_q1 VB VE 2.05e+05
ro_q1 VC VE 2.64e+06
g_q1 VC VE VB VE 1.52e-03
RC 0 VC 10k
RE VE 0 100k
R1 0 VB 100k
R2 VB 0 100k
C1 VB Vin 1µ
C2 N001 VE 1µ
C3 VC Vout 1µ
R5 N001 0 5k
V2 Vin 0 SINE(0 10m 1k)
